# Keil uVision project eBikeHeadlightProject.uvprojx, settings and files
target v1.0_STM32L151RBT6 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L151RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: eBikeHeadlight
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD
  c include: ..\;..\Libraries\CMSIS\Device\ST\STM32L1xx\Include;..\Libraries\STM32L1xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group User
    ../: stm32l1xx_conf.h main.c stm32l1xx_it.c SuperDebounce.c
  group STM32L1xx_StdPeriph_Driver
    ../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group CMSIS
    ../: system_stm32l1xx.c
    ../Libraries/CMSIS/Include/: core_cm3.h
  group MDK-ARM
    ../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l1xx_md.s
